options:
  parameters:
    author: RupsaMC
    generate_options: qt_gui
    id: reed_solomon
    output_language: python
    title: Reed-Solomon Encoder Example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
    vlen: '128'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
    vlen: '128'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: byte
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '122'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,2,3,4,5,6,7,8,9,10,11,12,13,14,15,16,17,18,19,20,21,22,23,24,25,26,27,28,29,30,31,32,33,34,35,36,37,38,39,40,41,42,43,44,45,46,47,48,49,50,51,52,53,54,55,56,57,58,59,60,61,62,63,64,65,66,67,68,69,70,71,72,73,74,75,76,77,78,79,80,81,82,83,84,85,86,87,88,89,90,91,92,93,94,95,96,97,98,99,100,101,102,103,104,105,106,107,108,109,110,111,112,113,114,115,116,117,118,119,120,121)
  states: {}
- name: dtv_catv_reed_solomon_enc_bb_0
  id: dtv_catv_reed_solomon_enc_bb
  parameters: {}
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '128'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    vlen: '128'
    x_start: '0'
    x_step: '1.0'
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_char_to_float_1, '0', qtgui_vector_sink_f_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_source_x_0, '0', dtv_catv_reed_solomon_enc_bb_0, '0']
- [dtv_catv_reed_solomon_enc_bb_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
